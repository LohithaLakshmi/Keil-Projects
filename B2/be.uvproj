# Keil uVision project be.uvproj, settings and files
target Target 1 (MCS-51)
  device: T8051 Cadence Design Systems Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)
  output: be
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 b2.c
